# Repository therickthe/therick_tht

## KiCad design PCB_THT/therick_THT.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: D; Diode_Long
H1, H2, H3, H4, H5, H6: MountingHole; Generic-Mounthole
J1: TYPE-C-31-M12_13; TYPE-C-31-M-12
J2: 4PIN; PinHeader_1x4_P2.54mm_Vertical_B_mask
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K28, K29, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K42, K43, K44, K45, K46, K47, K48: KEYSW; MXOnly-1U-NoLED
SW1: SW_PUSH; SKQG-1155865
U1: ProMicro; ArduinoProMicro
U2: HOLE; rick_large

Connections:
/col0: K1.1, K13.1, K25.1, K37.1, U1.20 (F4)
/col1: K2.1, K14.1, K26.1, K38.1, U1.19 (F5)
/col2: K3.1, K15.1, K27.1, K39.1, U1.18 (F6)
/col3: K4.1, K16.1, K28.1, K40.1, U1.17 (F7)
/col4: K5.1, K17.1, K29.1, K41.1, U1.16 (B1)
/col5: K6.1, K18.1, K30.1, K42.1, U1.15 (B3)
/col6: K7.1, K19.1, K31.1, K43.1, U1.14 (B2)
/col7: K8.1, K20.1, K32.1, K44.1, U1.13 (B6)
/col8: K9.1, K21.1, K33.1, K45.1, U1.7 (D4)
/col9: K10.1, K22.1, K34.1, K46.1, U1.8 (C6)
/col10: K11.1, K23.1, K35.1, K47.1, U1.9 (D7)
/col11: K12.1, K24.1, K36.1, K48.1, U1.10 (E6)
/row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, U1.1 (TX)
/row1: D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, D21.1, D22.1, D23.1, D24.1, U1.2 (RX)
/row2: D25.1, D26.1, D27.1, D28.1, D29.1, D30.1, D31.1, D32.1, D33.1, D34.1, D35.1, D36.1, U1.5 (SCL)
/row3: D37.1, D38.1, D39.1, D40.1, D41.1, D42.1, D43.1, D44.1, D45.1, D46.1, D47.1, D48.1, U1.6 (SDA)
GND: SW1.1, U1.23 (GND)
unnamed: D1.2, K1.2
unnamed: D2.2, K2.2
unnamed: D3.2, K3.2
unnamed: D4.2, K4.2
unnamed: D5.2, K5.2
unnamed: D6.2, K6.2
unnamed: D7.2, K7.2
unnamed: D8.2, K8.2
unnamed: D9.2, K9.2
unnamed: D10.2, K10.2
unnamed: D11.2, K11.2
unnamed: D12.2, K12.2
unnamed: D13.2, K13.2
unnamed: D14.2, K14.2
unnamed: D15.2, K15.2
unnamed: D16.2, K16.2
unnamed: D17.2, K17.2
unnamed: D18.2, K18.2
unnamed: D19.2, K19.2
unnamed: D20.2, K20.2
unnamed: D21.2, K21.2
unnamed: D22.2, K22.2
unnamed: D23.2, K23.2
unnamed: D24.2, K24.2
unnamed: D25.2, K25.2
unnamed: D26.2, K26.2
unnamed: D27.2, K27.2
unnamed: D28.2, K28.2
unnamed: D29.2, K29.2
unnamed: D30.2, K30.2
unnamed: D31.2, K31.2
unnamed: D32.2, K32.2
unnamed: D33.2, K33.2
unnamed: D34.2, K34.2
unnamed: D35.2, K35.2
unnamed: D36.2, K36.2
unnamed: D37.2, K37.2
unnamed: D38.2, K38.2
unnamed: D39.2, K39.2
unnamed: D40.2, K40.2
unnamed: D41.2, K41.2
unnamed: D42.2, K42.2
unnamed: D43.2, K43.2
unnamed: D44.2, K44.2
unnamed: D45.2, K45.2
unnamed: D46.2, K46.2
unnamed: D47.2, K47.2
unnamed: D48.2, K48.2
unnamed: SW1.2, U1.22 (RST)

Board: 2 copper layers, 227.0 x 74.6 mm, 108 parts (51 on the bottom side), 66 nets.

Other parts of the board:
H7, H8: MountingHole; Generic-Mounthole
U3: HOLE; THERICK

## Commit log

2019-11-24 Add files
2019-11-24 Add gerber
2019-11-24 Gerber
2019-11-25 Slimmed down USB port
2019-11-27 Added GND to VBUS
2019-11-27 Add image
2019-11-27 Add images
2020-02-08 Update a stupid MacOS file
2020-05-19 Removed Type C Connector
    Only uses a Pro Micro/Elite C now
2020-05-24 Add v 1.0
